Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-14T08:31:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 14 08:31:30 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{27D46B1C-6AFC-453F-AE92-6755B75A4456}\ifc * Database version: 5507 * Database creation date: Thu Jun 14 08:31:27 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 14 08:31:28 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 14 08:31:28 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 7448 Shower faucet with shower set, 7448(2016):7448 Shower faucet with shower set:329171
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 225.5 mm; NominalHeight: 1030 mm; NominalWidth: 351.5 mm
Type - General - Author: Convergo AB; BIMObjectName: 7448(2016); ConvergoRefNr: 0087-1806-0067-FI; ExpiringDate: 12/2018; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Thermostatic shower faucet with spout; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 31/05/2018
Type - Green Building Properties - EAN Number: 6414150079092; LVI Number: 6310807; Noise Class: I (ISO 3822) Oras lab.; STF Certificate: STF VTT-RTH-00085-17
Type - Identity Data - Class: Thermostatic; Group: Bath and shower faucets; Manufacturer: Oras; Market: INT;FIN;POL;EST;RUS; Model: 7448 Shower faucet with shower set; Name_en: 7448 Shower faucet with shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7448; Product Datasheet: https://www.oras.com/datasheet/7448/en; Product Family: Oras Nova; Product URL: https://www.oras.com/en/products/oras-nova/product/7448/; Type Name: 7448 Shower faucet with shower set
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Eco Flow At 300kPa: 0.00600349 m3/s; Flow: EcoFlow control; Flow Rate At 300kPa: 0.00847552 m3/s; Installation Type: Wall mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 220000 Pa; Shower Parts: Shower rail, hand shower, shower set, shower hose
Type - Other - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, shower; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7448(2016); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7448; Name: 7448 Shower faucet with shower set; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 290x105.5x72 mm; Shower: 222.5x225.5x701 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7448; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7448 Shower faucet with shower set
Constraints - DefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.675576 m2; ConnectorDirection: 1; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 90 deg; Volume: 0.0816535 m3
Identity Data - Mark: 18
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 7448(2016): 7448 Shower faucet with shower set; Family and Type: 7448(2016): 7448 Shower faucet with shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7448(2016): 7448 Shower faucet with shower set; Type Id: 7448(2016): 7448 Shower faucet with shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
